Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:26:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:26:48 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{50A75D5B-B642-41D0-BFFE-1BC07229BCE0}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:26:44 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:26:44 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:26:44 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HA20 LE PRO, Construction_Aerial-Equipment_Haulotte_HA20-LE-PRO_FR:HA20 LE PRO:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Yellow, Metal - Haulotte - White, Blue, Red, Metal - Haulotte - Black, Metal - Haulotte - Grey
Type - Autre(Type) - Catégorie: Equipement spécialisé; Masse Machine (CE): 9785 kg (21572 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_HA20-LE-PRO_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Respect de son environnement Architecture électrique Fonctionnement propre et silencieux pour le respect des personnes présentes à proximité Polyvalence pour un travail partout à tout moment Roues non-marquantes pour usage en intérieur (option) 4 roues motrices pour un usage tout terrain Utilisation silencieuse pour un travail à toute heure Productivité optimale Rotation continue 360° (modèle PRO) Mouvements rapides, proportionnels et simultanés Charge panier de 250 kg Double charge, jusqu'à 350 kg (option) Autonomie extensible Autonomie d'une journée type de travail Chargeur multi-tension embarqué Recharge de batteries via la génératrice de courant; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA 20; Nom du type: HA20 LE PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://bimobject.com/haulotte/product/ha20-le-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.fr
Type - Données(Type) - Angle de Levage Pendulaire: -70° / +70°; Angle de Rotation Plateforme: 180° ( +90°/-90°); Angle de Rotation Tourelle: 360° continuous; Angle D'oscillation: 2°; Batteries: 12 x 6 V - 435 Ah; Capacité Maximum: 2 persons - 250 kg / option 350 kg (2 persons - 550 lbs / option 770 lbs); Déport Arrière: 41 cm (1 ft 4 in); Déport Maximum: 11,91 m (39 ft); Devers: 4°; Dimensions Plateforme: 1.83 x 0.80 m (8 ft x 3 ft); Empattement: 2,5 m ( 8 ft 2 in); Garde au Sol: 46 cm (1 ft 6 in); Hauteur de Transport: 3 m ( 9 ft 10 in); Hauteur Plateforme: 18,76 m (61 ft 6 in); Hauteur Repliée: 2,5 m (8 ft 2 in); Hauteur Travail: 20,76 m (68 ft 8 in); Largeur Hors Tout: 2,41 m (7 ft 10 in); Longueur de Transport: 6,19 m ( 20 ft 3 in); Longueur Hors Tout: 8,54 m (28 ft); Longueur Pendulaire: 1 m 8 ( 5 ft 10 in); Pente Maximum: 45%; Pneus: Cured-on solid tires 1025 x 365 mm (Cured-on solid tires 40,4 x 14,4 in); Point D'articulation: 8,52 m (27 ft 11 in); Pression Max au Sol: 12.9 daN/m²; Rayon de Braquage Exterieur: 3,7 m (12 ft 4 in); Rayon de Braquage Interieur: 1,6m (5 ft 3 in); Vitesse de Translation: 0,7 - 5 kmh (0,4 - 3,1mph)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HA20 LE PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HA20-LE-PRO_FR: HA20 LE PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HA20-LE-PRO_FR: HA20 LE PRO; ID du type: Construction_Aerial-Equipment_Haulotte_HA20-LE-PRO_FR: HA20 LE PRO; Turntable Rotation Control: 0 deg; Type: Construction_Aerial-Equipment_Haulotte_HA20-LE-PRO_FR: HA20 LE PRO
Construction - Abaque de Travail: no; Angle de Levage Flèche: 45 deg; Angle de Levage Pendulaire: -45 deg; Angle de Rotation Tourelle: 0 deg; Hauteur Maxi Point D'articulation: 8.09 m; Rayon de Braquage Exterieur: no; Rotation Panier: 0 deg; Sortie du Telescope: 9.355 m; Zone de Travail: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 115.887 m2; Volume: 21.6554 m3
Phase de construction - Phase de création: Nouvelle construction
Visibilité - Marque: yes
