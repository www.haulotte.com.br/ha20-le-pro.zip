Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:28:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:28:53 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{C7FC10EB-AE8D-4962-9D79-D176E0DCBCDC}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:28:49 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:28:49 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:28:49 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HA61 LE PRO, Construction_Aerial-Equipment_Haulotte_HA61-LE-PRO_US:HA61 LE PRO:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Yellow, Metal - Haulotte - White, Blue, Red, Metal - Haulotte - Black, Metal - Haulotte - Grey
Type - Autre(Type) - Catégorie: Equipement spécialisé; Machine Weight: 9785 kg (21572 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_HA61-LE-PRO_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Performance & ease of use Best lifting speed of 48 sec. Industry leading working envelope with an outreach of 12.2 m Fully proportional and simultaneous movements Ease of transport Excellent robustness Rugged hoods with ergonomic handle Long lasting structural design Maximized total cost of ownership Haulotte Activ'Screen (on board diagnostic) Haulotte Stop Emission System: automatically turns the engine off & on Exclusive modular basket with upper control box cover and tool tray Easy access to all components Best comfort and safety feeling Haulotte Activ'Shield Bar 2.0; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA61 LE PRO; Nom du type: HA61 LE PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ha20-le-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Batteries: 12 x 6 V - 435 Ah; Drive Speed: 0,7 - 5 kmh (0,4 - 3,1mph); Gradeability: 0.45; Ground Clearance: 46 cm (1 ft 6 in); Height - Storage / Transport: 3 m ( 9 ft 10 in); Height - Stowed: 2,5 m (8 ft 2 in); Horizontal Outreach: 11,91 m (39 ft); Jib Length: 1 m 8 ( 5 ft 10 in); Lenght - Storage/Transport: 6,19 m ( 20 ft 3 in); Length - Stowed: 8,54 m (28 ft); Lift Capacity: 2 persons - 250 kg / option 350 kg (2 persons - 550 lbs / option 770 lbs); Max Ground Pressure of Wheel on Paved Ground: 129 Pa; Oscillation Angle: 2 deg; Platform Height: 18,76 m (61 ft 6 in); Platform Rotation: 180° ( +90°/-90°); Platform Size: 1.83 x 0.80 m (8 ft x 3 ft); Tailswing: 41 cm (1 ft 4 in); Tilt: 4 deg; Tires: Cured-on solid tires 1025 x 365 mm (Cured-on solid tires 40,4 x 14,4 in); Turnable Rotation: 360° continuous; Turning Radius - Inside: 1,6m (5 ft 3 in); Turning Radius - Outside: 3,7 m (12 ft 4 in); Up and Over Clearance: 8,52 m (27 ft 11 in); Vertical Jib Rotation Angle: -70° / +70°; Wheelbase: 2,5 m ( 8 ft 2 in); Width: 2,41 m (7 ft 10 in); Working Height: 20,76 m (68 ft 8 in)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HA61 LE PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HA61-LE-PRO_US: HA61 LE PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HA61-LE-PRO_US: HA61 LE PRO; ID du type: Construction_Aerial-Equipment_Haulotte_HA61-LE-PRO_US: HA61 LE PRO; Turntable Rotation Control: 0 deg; Type: Construction_Aerial-Equipment_Haulotte_HA61-LE-PRO_US: HA61 LE PRO
Construction - Boom Rotation Angle: 45 deg; Maximum Boom Articulation Point Height: 8.09 m; Platform Rotation Angle: 0 deg; Reach Diagram: no; Telescopic Extend: 7.355 m; Turnable Rotation: 0 deg; Turning Radius: no; Vertical Jib Rotation Angle: -45 deg; Working Area: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 115.887 m2; Volume: 21.6554 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
